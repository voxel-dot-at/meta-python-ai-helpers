FILESEXTRAPATHS:append := "${THISDIR}/onnxruntime-1.17/:"

SRC_URI += " file://fix-auto-reference.patch "

